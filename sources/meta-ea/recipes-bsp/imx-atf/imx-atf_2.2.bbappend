FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += " file://imx-atf-uart4.patch "

